# Keil uVision project ICU_STM32.uvprojx, settings and files
target ICU_STM32 (6180000::V6.18::ARMCLANG)
  device: STM32L031E6Yx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: ICU_STM32 +hex
  AfterMake: fromelf.exe --bin -o ./ICU_STM32/ICU_STM32_APP.bin ./ICU_STM32/ICU_STM32.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=2097000,HSI_VALUE=16000000,LSI_VALUE=37000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32L031xx,USER_VECT_TAB_ADDRESS
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\Drivers\PTX30W\ptx;..\Drivers\PTX30W\plat;..\Drivers\PTX30W\ptx\ndef
  memory RVCT4: ROM 0x8002000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x1c00
  memory RVCT10: RAM 0x20001c00 size 0x400
  group Application/MDK-ARM
    ./: startup_stm32l031xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c iwdg.c tim.c usart.c stm32l0xx_it.c protocol.c bsp.c flash.c info.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_ll_adc.c stm32l0xx_ll_dma.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_ll_i2c.c stm32l0xx_ll_pwr.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_lptim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/PTX30W
    ../Drivers/PTX30W/plat/: ptxPlat_I2C.c ptxPlat_IRQ.c ptxPlat_Timer.c
    ../Drivers/PTX30W/ptx/: ptx30w.c ptx30w_ConfigHelper.c ptx30w_Crc.c ptx30w_Hip.c ptx30w_Hip_Int.c ptx30w_Nsc.c
    ../Core/Src/: ptx30w_drv.c
software components: CMSIS:CORE 5.6.0
